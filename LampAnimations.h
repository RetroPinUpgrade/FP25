#ifndef LAMP_ANIMATIONS_H

#include "RPU_Config.h"
#include "RPU.h"



// This file can define a series of animations, stored 
// with each lamp as a bit in the following array.
// Lamp 0 = the first bit of the first byte, so "{0x01," below.
// The animations can be played with either of the helper functions
// at the bottom of this file.
// 
// These demonstration animations should be replaced
// or removed for each specific implementation.

// Lamp animation arrays
// PinballRefresh.com Animation Data
#define NUM_LAMP_ANIMATIONS 4
#define LAMP_ANIMATION_STEPS 24
#define NUM_LAMP_ANIMATION_BYTES 8

byte LampAnimations[NUM_LAMP_ANIMATIONS][LAMP_ANIMATION_STEPS][NUM_LAMP_ANIMATION_BYTES] = {
  // Radar Sweep 1 (idx 0)
  {
    {0x02, 0x07, 0x00, 0x23, 0x81, 0x00, 0x00, 0x00},
    {0x08, 0x0F, 0x00, 0x65, 0x81, 0x00, 0x01, 0x00},
    {0x08, 0x0E, 0x00, 0xC5, 0x80, 0x00, 0x01, 0x00},
    {0x18, 0x08, 0x00, 0xCD, 0xE0, 0x48, 0x01, 0x00},
    {0x79, 0xE8, 0xBF, 0xCD, 0x64, 0x4F, 0x01, 0x00},
    {0xF9, 0xE8, 0xBF, 0x9D, 0x7C, 0x7F, 0x01, 0x00},
    {0xF1, 0xE0, 0xBF, 0x99, 0x7C, 0x7F, 0x00, 0x00},
    {0xF5, 0xF0, 0xBF, 0x19, 0x7E, 0xFF, 0x00, 0x00},
    {0xE7, 0xF0, 0xBF, 0x13, 0x1E, 0xB7, 0x00, 0x00},
    {0x86, 0x11, 0x00, 0x33, 0x1B, 0xB0, 0x00, 0x00},
    {0x06, 0x17, 0x00, 0x23, 0x03, 0x80, 0x00, 0x00},
    {0x06, 0x17, 0x00, 0x23, 0x81, 0x80, 0x00, 0x00},
    {0x02, 0x07, 0x00, 0x23, 0x81, 0x00, 0x00, 0x00},
    {0x08, 0x0F, 0x00, 0x65, 0x81, 0x00, 0x01, 0x00},
    {0x08, 0x0E, 0x00, 0xC5, 0x80, 0x00, 0x01, 0x00},
    {0x18, 0x08, 0x00, 0xCD, 0xE0, 0x48, 0x01, 0x00},
    {0x79, 0xE8, 0xBF, 0xCD, 0x64, 0x4F, 0x01, 0x00},
    {0xF9, 0xE8, 0xBF, 0x9D, 0x7C, 0x7F, 0x01, 0x00},
    {0xF1, 0xE0, 0xBF, 0x99, 0x7C, 0x7F, 0x00, 0x00},
    {0xF5, 0xF0, 0xBF, 0x19, 0x7E, 0xFF, 0x00, 0x00},
    {0xE7, 0xF0, 0xBF, 0x13, 0x1E, 0xB7, 0x00, 0x00},
    {0x86, 0x11, 0x00, 0x33, 0x1B, 0xB0, 0x00, 0x00},
    {0x06, 0x17, 0x00, 0x23, 0x03, 0x80, 0x00, 0x00},
    {0x06, 0x17, 0x00, 0x23, 0x81, 0x80, 0x00, 0x00}
  },
  // Center Out 1 (idx 1)
  {
    {0x00, 0x00, 0x80, 0x25, 0x00, 0x00, 0x00, 0x00},
    {0x00, 0x00, 0x80, 0x7F, 0x00, 0x00, 0x00, 0x00},
    {0x08, 0x00, 0xA0, 0x7F, 0x00, 0x00, 0x00, 0x00},
    {0x0C, 0x00, 0xB0, 0x7E, 0x01, 0x00, 0x00, 0x00},
    {0x0C, 0x08, 0xB8, 0x0C, 0x81, 0x20, 0x00, 0x00},
    {0x0C, 0x08, 0x38, 0x08, 0x81, 0x20, 0x01, 0x00},
    {0x06, 0x0F, 0x1C, 0x00, 0x81, 0x20, 0x01, 0x00},
    {0x06, 0x1F, 0x1E, 0x00, 0x82, 0x71, 0x01, 0x00},
    {0x02, 0x1F, 0x0F, 0x00, 0xC2, 0x51, 0x01, 0x00},
    {0x02, 0x9F, 0x07, 0x00, 0xE2, 0xD1, 0x01, 0x00},
    {0x02, 0xD7, 0x03, 0x00, 0x62, 0xD3, 0x01, 0x00},
    {0x02, 0xF0, 0x01, 0x00, 0x78, 0xD3, 0x01, 0x00},
    {0x01, 0xF0, 0x00, 0x80, 0x38, 0xD3, 0x00, 0x00},
    {0x01, 0x60, 0x00, 0x80, 0x18, 0x9F, 0x00, 0x00},
    {0x01, 0x20, 0x00, 0x80, 0x18, 0x9E, 0x00, 0x00},
    {0x01, 0x00, 0x00, 0x80, 0x00, 0x0E, 0x00, 0x00},
    {0x80, 0x00, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00},
    {0x80, 0x00, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00},
    {0xC0, 0x00, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00},
    {0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00},
    {0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00},
    {0xF0, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00},
    {0x10, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00},
    {0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00}
  },
  // Bottom to Top 1 (idx 2)
  {
    {0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00},
    {0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00},
    {0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00},
    {0x01, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00},
    {0x00, 0x60, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00},
    {0x00, 0x80, 0x00, 0x00, 0x68, 0x00, 0x00, 0x00},
    {0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x00},
    {0x00, 0x10, 0x04, 0x00, 0x00, 0x80, 0x01, 0x00},
    {0x02, 0x08, 0x08, 0x00, 0x00, 0x00, 0x00, 0x00},
    {0x0C, 0x00, 0x30, 0x00, 0x00, 0x00, 0x00, 0x00},
    {0x00, 0x00, 0x80, 0x42, 0x81, 0x00, 0x00, 0x00},
    {0x00, 0x06, 0x00, 0x21, 0x00, 0x00, 0x00, 0x00},
    {0x00, 0x01, 0x00, 0x14, 0x00, 0x00, 0x00, 0x00},
    {0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x00},
    {0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00},
    {0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00},
    {0x00, 0x00, 0x00, 0x00, 0x02, 0x60, 0x00, 0x00},
    {0x00, 0x00, 0x00, 0x80, 0x00, 0x01, 0x00, 0x00},
    {0x00, 0x00, 0x00, 0x00, 0x00, 0x12, 0x00, 0x00},
    {0x00, 0x00, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00},
    {0x00, 0x00, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00},
    {0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00},
    {0x70, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00},
    {0x00, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00}
  },
  // Radar Sweep 2 (idx 3)
  {
    {0x07, 0x10, 0x00, 0x00, 0x19, 0x00, 0x00, 0x00},
    {0x35, 0x00, 0x00, 0x8E, 0x01, 0x48, 0x00, 0x00},
    {0xF1, 0xE0, 0xBF, 0x7F, 0x04, 0x7F, 0x00, 0x00},
    {0xC9, 0x07, 0x00, 0x70, 0x86, 0x30, 0x00, 0x00},
    {0x09, 0x0F, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00},
    {0x01, 0x08, 0x00, 0x00, 0x60, 0x00, 0x01, 0x00},
    {0x01, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00},
    {0x03, 0x10, 0x00, 0x00, 0x18, 0x80, 0x00, 0x00},
    {0x07, 0x10, 0x00, 0x00, 0x19, 0x00, 0x00, 0x00},
    {0x35, 0x00, 0x00, 0x8E, 0x01, 0x48, 0x00, 0x00},
    {0xF1, 0xE0, 0xBF, 0x7F, 0x04, 0x7F, 0x00, 0x00},
    {0xC9, 0x07, 0x00, 0x70, 0x86, 0x30, 0x00, 0x00},
    {0x09, 0x0F, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00},
    {0x01, 0x08, 0x00, 0x00, 0x60, 0x00, 0x01, 0x00},
    {0x01, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00},
    {0x03, 0x10, 0x00, 0x00, 0x18, 0x80, 0x00, 0x00},
    {0x07, 0x10, 0x00, 0x00, 0x19, 0x00, 0x00, 0x00},
    {0x35, 0x00, 0x00, 0x8E, 0x01, 0x48, 0x00, 0x00},
    {0xF1, 0xE0, 0xBF, 0x7F, 0x04, 0x7F, 0x00, 0x00},
    {0xC9, 0x07, 0x00, 0x70, 0x86, 0x30, 0x00, 0x00},
    {0x09, 0x0F, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00},
    {0x01, 0x08, 0x00, 0x00, 0x60, 0x00, 0x01, 0x00},
    {0x01, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00},
    {0x03, 0x10, 0x00, 0x00, 0x18, 0x80, 0x00, 0x00}
  }
};

boolean FetchAnimationBytes(byte *destinationArray, byte animationNum, byte frameNum) {
  if (destinationArray==NULL) return false;
  if (animationNum >= NUM_LAMP_ANIMATIONS || frameNum >= LAMP_ANIMATION_STEPS) return false;
  memcpy(destinationArray, LampAnimations[animationNum][frameNum], NUM_LAMP_ANIMATION_BYTES);
  return true;
}




void ShowLampAnimation(byte animationNum, unsigned long divisor, unsigned long baseTime, byte subOffset, boolean dim, boolean reverse = false, byte keepLampOn = 99) {
  if (animationNum>=NUM_LAMP_ANIMATIONS) return;
  
  byte currentStep = (baseTime / divisor) % LAMP_ANIMATION_STEPS;
  if (reverse) currentStep = (LAMP_ANIMATION_STEPS - 1) - currentStep;

  byte curBitmask;
  byte *currentLampOffsetByte = LampAnimations[animationNum][(currentStep + subOffset) % LAMP_ANIMATION_STEPS];
  byte *currentLampByte = LampAnimations[animationNum][currentStep];

  byte lampNum = 0;
  for (int byteNum = 0; byteNum < NUM_LAMP_ANIMATION_BYTES; byteNum++) {
    curBitmask = 0x01;
    
    for (byte bitNum = 0; bitNum < 8; bitNum++) {

      byte lampOn = false;
      lampOn = (*currentLampByte) & curBitmask;

      // if there's a subOffset, turn off lights at that offset
      if (subOffset) {
        byte lampOff = true;
        lampOff = (*currentLampOffsetByte) & curBitmask;
        if (lampOff && lampNum != keepLampOn && !lampOn) RPU_SetLampState(lampNum, 0);
      }

      if (lampOn) RPU_SetLampState(lampNum, 1, dim);

      curBitmask *= 2;
      lampNum += 1;
    }
    currentLampByte += 1;
    currentLampOffsetByte += 1;
  }
}


void ShowLampAnimationSingleStep(byte animationNum, byte currentStep, byte *lampsToAvoid = NULL) {
  if (animationNum>=NUM_LAMP_ANIMATIONS) return;
  if (currentStep>=LAMP_ANIMATION_STEPS) return;
  
  byte lampNum = 0;
  byte *currentLampByte = LampAnimations[animationNum][currentStep];
  byte *currentAvoidByte = lampsToAvoid;
  byte curBitmask;
  
  for (int byteNum = 0; byteNum < NUM_LAMP_ANIMATION_BYTES; byteNum++) {
    curBitmask = 0x01;
    for (byte bitNum = 0; bitNum < 8; bitNum++) {

      boolean avoidLamp = false;
      if (currentAvoidByte!=NULL) {
        if ((*currentAvoidByte) & curBitmask) avoidLamp = true;
      }

      if (!avoidLamp /*&& (*currentLampByte)&curBitmask*/) RPU_SetLampState(lampNum, (*currentLampByte)&curBitmask);

      lampNum += 1;
      curBitmask *= 2;
    }
    currentLampByte += 1;
    if (currentAvoidByte!=NULL) currentAvoidByte += 1;
  }
}

void FlashAnimationSteps(byte animationNum, byte startStep, int flashSpeed) {
  if (animationNum>=NUM_LAMP_ANIMATIONS) return;
  if (startStep>=LAMP_ANIMATION_STEPS) return;
  
  byte lampNum = 0;
  byte *currentLampByte = LampAnimations[animationNum][startStep];
  byte curBitmask;
  
  lampNum = 0;
  for (int byteNum = 0; byteNum < NUM_LAMP_ANIMATION_BYTES; byteNum++) {
    curBitmask = 0x01;
    for (byte bitNum = 0; bitNum < 8; bitNum++) {

      if ((*currentLampByte)&curBitmask) RPU_SetLampState(lampNum, 1, 0, flashSpeed);

      lampNum += 1;
      curBitmask *= 2;
    }
    currentLampByte += 1;
  }
}





#define LAMP_ANIMATIONS_H
#endif
